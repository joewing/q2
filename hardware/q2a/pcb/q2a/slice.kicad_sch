File: hardware/q2a/pcb/q2a/slice.kicad_sch (KiCad schematic)
At the start: 3 parts, among them U14 Slice

Commit message: Board updates.
Parts:
- renumbered C22 to C23, U14 to U13
